# Keil uVision project ram.uvprojx, settings and files
target TEST_ROM (6220000::V6.22::..\..\AC\622)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app
  AfterMake: after_build.bat $J #L @L
  c flags: Optim=7 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X3K,CONFIG_SOC_CORE_APPPROCESSOR CONFIG_LOGGING_BUFFER_LOG CONFIG_LOGGING_MINIMIZE_BOOT_LOG DCI_DEBUG_REG_DUMP=1
  c misc: --include rom_defines.h -gdwarf-3
  c include: ..\..\..\..\kernel\soc\rtl87x3k;..\..\..\..\kernel\staging\rtl87x3k\inc\ap;..\..\..\driver\pinmux\inc;..\..\..\driver;..\..\..\boot\ap_boot\inc;..\..\..\..\kernel\logging\inc\rtl87x3k;..\..\..\..\kernel\util\inc;..\..\..\..\kernel\linker\inc;..\..\..\..\kernel\logging\src\rtl87x3k;..\..\..\..\kernel\logging\src;..\..\..\..\kernel\arch\arm\cmsis\CMSIS_5-5.9.0\CMSIS\Core\Include;..\..\..\driver\irq\inc;..\..\..\driver\rcc\inc;..\..\..\driver\uart\inc;..\..\..\driver\dma\inc;..\..\..\driver\pinmux\inc;..\..\..\driver\utils;..\..\..\..\kernel\debug\src;..\..\..\..\kernel\soc\rtl87x3k\ap;..\..\..\..\boards\boot\inc;..\..\..\..\boards\boot\inc\rtl87x3k;..\..\..\..\kernel\memory\inc\rtl87x3k;..\..\..\boards\config\memory\rtl87x3k\core_ram\ap;..\..\..\boards\config\memory\rtl87x3k\core_ram\ap;..\..\..\..\kernel\os\osif\inc;..\..\..\..\kernel\util\inc\rtl87x3k;..\..\inc\ap;..\..\src\ap;..\..\src\coremark;..\..\src\coremark\simple;..\..\src\dhrystone;.\inc;..\..\..\driver\rtc\inc;..\..\..\..\driver\i2c\inc;..\..\..\..\driver\i2c\src\device\rtl87x3k;..\..\..\..\driver;..\..\..\..\driver\rtc\inc;..\..\..\..\driver\qdec\inc;..\..\..\driver\wdt\inc;..\..\..\cpu_component;..\..\..\..\kernel\debug\inc\rtl87x3k;..\..\..\..\kernel\logging\inc;..\..\..\..\kernel\sys\inc;..\..\..\..\kernel\memory\inc\rtl87x3k\ap;..\..\..\..\driver\spi\inc;..\..\..\..\driver\spi\src\device\rtl87x3k;..\..\..\..\driver\led\inc;..\..\..\..\driver\led\src\device\rtl87x3k;..\..\..\..\driver\ir\inc;..\..\..\..\driver\ir\src\device\rtl87x3k;..\..\..\driver\timer\src\device\rtl87x3k;..\..\..\driver\gpio\inc;..\..\..\..\driver\gpio\inc;..\..\..\..\kernel\debug\inc;..\..\..\..\driver\lpc\inc;..\..\..\..\driver\lpc\src\device\rtl87x3k;..\..\..\driver\timer\inc;..\..\..\driver\gtc\inc;..\..\..\driver\keyscan\inc;..\..\..\driver\keyscan\src\device\rtl87x3k;..\..\..\driver\pinmux\src\device\rtl87x3k;..\..\..\..\boards\config\flash_map\rtl87x3k;..\..\..\driver\spi3w_m\inc;..\..\..\driver\pinmux\inc\rtl87x2j;..\..\..\hw_mutex\inc;..\..\..\driver\debug\inc;..\..\..\boot;..\..\..\..\kernel\arch\common;..\..\..\..\driver\adp\inc;..\..\..\driver\gpio\inc;..\..\src\peripheral\ap;..\..\..\..\kernel\sys\inc\rtl87x3k;..\..\..\..\kernel\sys\src\rtl87x3k;..\..\..\..\..\display\hardware\dci\inc;..\..\..\..\..\display\hardware\dci\src\device\rtl87x3k;..\..\..\..\..\display\hardware\dci\test
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app_rom.sct
  link misc: --pad=0xff --diag_suppress=L6314,6480 --datacompressor=off --no_remove --entry=Reset_Handler --startup=Reset_Handler
  group platform
    ../../../../kernel/soc/rtl87x3k/ap/: vector_table_auto_gen.c vector_table.c
    ../../src/system_init/src/ap/: system_bb3.c
    ../../../cpu_component/: cpu_cfg.c
    ../../../../kernel/debug/src/rtl87x3k/: dbg_cfg.c
    ../../../boot/ap_boot/src/: boot_cfg.c occd_boot_config_module.c
    ../../../../kernel/util/src/: atomic.c
    ../../../../kernel/sys/src/timestamp/rtl87x3k/: timestamp.c
  group peripheral
    ../../../driver/pinmux/src/device/rtl87x3k/: rtl_pinmux.c rtl_wakeup.c
    ../../../driver/uart/src/device/rtl87x3k/: rtl_uart_int.c
    ../../../driver/uart/src/device/rtl_common/: rtl_uart.c
    ../../../driver/irq/src/device/rtl87x3k/: rtl_nvic.c
    ../../../driver/rcc/src/device/rtl87x3k/: rtl_rcc.c
    ../../../driver/dma/src/device/rtl_common/: rtl_dma.c
    ../../../driver/dma/src/device/rtl87x3k/: rtl_dma_int.c
    ../../../driver/rtc/src/device/rtl_common/: rtl_grtc.c
    ../../../driver/rtc/src/device/rtl87x3k/: rtl_grtc_int.c
    ../../../../driver/i2c/src/device/rtl_common/: rtl_i2c.c
    ../../../../driver/i2c/src/device/rtl87x3k/: rtl_i2c_int.c
    ../../../../driver/rtc/src/device/rtl_common/: rtl_rtc.c
    ../../../../driver/rtc/src/device/rtl87x3k/: rtl_rtc_int.c
    ../../../../driver/qdec/src/device/rtl_common/: rtl_lpqdec.c
    ../../../../driver/qdec/src/device/rtl87x3k/: rtl_lpqdec_int.c
    ../../../driver/wdt/src/device/rtl87x3k/: rtl_wdt.c
    ../../../../driver/spi/src/device/rtl_common/: rtl_spi.c
    ../../../../driver/spi/src/device/rtl87x3k/: rtl_spi_int.c
    ../../../../driver/led/src/device/rtl_common/: rtl_lpled.c
    ../../../../driver/led/src/device/rtl87x3k/: rtl_lpled_int.c
    ../../../../driver/ir/src/device/rtl_common/: rtl_ir.c
    ../../../../driver/ir/src/device/rtl87x3k/: rtl_ir_int.c
    ../../../../driver/gpio/src/device/rtl87x3k/: rtl_gpio.c rtl_gpio_int.c
    ../../../../driver/lpc/src/device/rtl87x3k/: rtl_lpc.c
    ../../../driver/timer/src/device/rtl87x3k/: rtl_timer.c rtl_timer_int.c
    ../../../driver/gtc/src/device/rtl_common/: rtl_gtc.c
  group hal
    ../../../driver/wdt/src/device/rtl87x3k/: hal_wdt.c
    ../../../../driver/gpio/src/device/rtl87x3k/: hal_gpio.c hal_gpio_int.c
    ../../../driver/debug/src/device/rtl87x3k/: debug_port.c
    ../../../../driver/adp/src/device/rtl_common/: adp_io.c
  group patch
    ../../../driver/pinmux/src/device/rtl87x3k/: patch_pinmux_function.c patch_wakeup_function.c
    ../../../driver/uart/src/device/rtl_common/: patch_uart_function.c patch_uart_share_function.c patch_uart_share_dma_function.c
    ../../../driver/irq/src/device/rtl87x3k/: patch_nvic_function.c
    ../../../driver/rcc/src/device/rtl87x3k/: patch_rcc_function.c
    ../../../driver/dma/src/device/rtl_common/: patch_dma_function.c
    ../../../driver/rtc/src/device/rtl_common/: patch_grtc_function.c
    ../../../driver/wdt/src/device/rtl87x3k/: patch_wdt_function.c
    ../../../driver/timer/src/device/rtl87x3k/: patch_timer_function.c
    ../../../driver/gtc/src/device/rtl_common/: patch_gtc_function.c
    ../../../driver/keyscan/src/device/rtl_common/: patch_keyscan_function.c
    ../../../driver/debug/src/device/rtl87x3k/: patch_debug_port_function.c
    ../../../../kernel/logging/src/rtl87x3k/: patch_log_function.c
    ../../../driver/gpio/src/device/rtl87x3k/: patch_gpio_function.c
    ../../../driver/spi3w_m/src/device/rtl_common/: patch_spi3w_m_function.c
    ../../../../kernel/sys/src/timestamp/rtl87x3k/: patch_timestamp_function.c
  group log
    ../../../../kernel/logging/src/: log_format.c log_format_patch_ptr.c
    ../../../../kernel/logging/src/rtl87x3k/: log_uart.c log_format_port.c log_module.c
  group util
    ../../../../kernel/util/src/: utils.c
  group main
    ../../Basic/src/ap/: main.c
  group sample
    ../../src/peripheral/sample/uart/: uart_dma.c
    ../../src/peripheral/sample/dma/: dma_mem_to_mem.c
    ../../src/peripheral/sample/gpio/gpio/: gpio_input_demo.c gpio_output_demo.c
    ../../src/peripheral/sample/gpio/hal_gpio/: hal_gpio_input_demo.c hal_gpio_output_demo.c
    ../../src/peripheral/sample/grtc/: grtc_demo.c
  group dci
    ../../../../../display/hardware/dci/src/device/rtl_common/: rtl_dci.c
    ../../../../../display/hardware/dci/src/device/rtl87x3k/: rtl_dci_int.c rtl_dci_dma.c
    ../../../../../display/hardware/dci/test/: dci_demo.c dci_demo_buf.c dci_demo_case.c dci_demo_irq.c dci_demo_signal.c
target TEST_RAM (6220000::V6.22::..\..\AC\622)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: app
  AfterMake: after_build.bat $J #L @L
  c flags: Optim=7 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X3K,CONFIG_SOC_CORE_APPPROCESSOR CONFIG_LOGGING_BUFFER_LOG CONFIG_LOGGING_MINIMIZE_BOOT_LOG, DCI_DEBUG_REG_DUMP=1
  c misc: --include rom_defines.h -gdwarf-3
  c include: ..\..\..\..\kernel\soc\rtl87x3k;..\..\..\..\kernel\staging\rtl87x3k\inc\ap;..\..\..\driver\pinmux\inc;..\..\..\driver;..\..\..\boot\ap_boot\inc;..\..\..\..\kernel\logging\inc\rtl87x3k;..\..\..\..\kernel\util\inc;..\..\..\..\kernel\linker\inc;..\..\..\..\kernel\logging\src\rtl87x3k;..\..\..\..\kernel\logging\src;..\..\..\..\kernel\arch\arm\cmsis\CMSIS_5-5.9.0\CMSIS\Core\Include;..\..\..\driver\irq\inc;..\..\..\driver\rcc\inc;..\..\..\driver\uart\inc;..\..\..\driver\dma\inc;..\..\..\driver\pinmux\inc;..\..\..\driver\utils;..\..\..\..\kernel\debug\src;..\..\..\..\kernel\soc\rtl87x3k\ap;..\..\..\..\boards\boot\inc;..\..\..\..\boards\boot\inc\rtl87x3k;..\..\..\..\kernel\memory\inc\rtl87x3k;..\..\..\boards\config\memory\rtl87x3k\core_ram\ap;..\..\..\..\kernel\os\osif\inc;..\..\..\..\kernel\util\inc\rtl87x3k;.\inc;..\..\src\system_init\inc;..\..\..\driver\rtc\inc;..\..\..\..\driver\i2c\inc;..\..\..\..\driver\i2c\src\device\rtl87x3k;..\..\..\..\driver;..\..\..\..\driver\rtc\inc;..\..\..\..\driver\qdec\inc;..\..\..\driver\wdt\inc;..\..\..\..\kernel\debug\inc\rtl87x3k;..\..\..\boot\ap_boot\inc;..\..\..\..\kernel\memory\inc\rtl87x3k\ap;..\..\..\cpu_component;..\..\..\..\kernel\logging\inc;..\..\..\..\kernel\sys\inc;..\..\..\..\driver\spi\inc;..\..\..\..\driver\spi\src\device\rtl87x3k;..\..\..\..\driver\led\inc;..\..\..\..\driver\led\src\device\rtl87x3k;..\..\..\..\driver\ir\inc;..\..\..\..\driver\ir\src\device\rtl87x3k;..\..\..\driver\timer\src\device\rtl87x3k;..\..\..\..\kernel\debug\src;..\..\..\..\driver\lpc\inc;..\..\..\..\driver\lpc\src\device\rtl87x3k;..\..\..\driver\timer\inc;..\..\..\driver\gtc\inc;..\..\..\driver\keyscan\inc;..\..\..\driver\keyscan\src\device\rtl87x3k;..\..\..\driver\pinmux\src\device\rtl87x3k;..\..\..\driver\spi3w_m\inc;..\..\..\driver\pinmux\inc\rtl87x2j;..\..\..\hw_mutex\inc;..\..\..\driver\debug\inc;..\..\..\driver\adp\inc;..\..\..\boot;..\..\..\..\kernel\arch\common;..\..\..\..\driver\adp\inc;..\..\..\driver\gpio\inc;;..\..\src\peripheral\ap;..\..\..\..\kernel\sys\inc\rtl87x3k;..\..\..\..\kernel\sys\src\rtl87x3k
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app_ram.sct
  link misc: as above
