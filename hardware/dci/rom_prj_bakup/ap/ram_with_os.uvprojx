# Keil uVision project ram_with_os.uvprojx, settings and files
target TEST_ROM (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ROM
  AfterMake: after_build.bat $J #L @L
  c flags: Optim=7 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X3K,CONFIG_SOC_CORE_APPPROCESSOR CONFIG_LOGGING_BUFFER_LOG CONFIG_LOGGING_MINIMIZE_BOOT_LOG RAM_PROJECT_SUPPORT_FREERTOS
  c misc: --include rom_defines.h --include cpu_setting.h -gdwarf-3
  c include: ..\..\src\peripheral\ap;..\..\..\..\kernel\arch\common;..\..\..\..\kernel\soc\rtl87x3k;..\..\..\..\kernel\staging\rtl87x3k\inc\ap;..\..\..\driver\pinmux\inc;..\..\..\driver;..\..\..\boot\ap_boot\inc;..\..\..\..\kernel\logging\inc\rtl87x3k;..\..\..\..\kernel\linker\inc;..\..\..\..\kernel\logging\src\rtl87x3k;..\..\..\..\kernel\logging\src;..\..\..\..\kernel\arch\arm\cmsis\CMSIS_5-5.9.0\CMSIS\Core\Include;..\..\..\driver\irq\inc;..\..\..\driver\rcc\inc;..\..\..\driver\uart\inc;..\..\..\driver\dma\inc;..\..\..\driver\pinmux\inc;..\..\..\driver\utils;..\..\..\..\kernel\debug\src;..\..\..\..\kernel\soc\rtl87x3k\ap;..\..\..\..\boards\boot\inc;..\..\..\..\boards\boot\inc\rtl87x3k;..\..\..\..\kernel\memory;..\..\..\..\kernel\util\inc\rtl87x3k;.\inc;..\..\src\system_init\inc;..\..\os\freertos\portable\GCC\ARM_CM33_NTZ;..\..\os;..\..\..\driver\pinmux\src\device\rtl87x3k;..\..\..\driver\rcc\src\device\rtl87x3k;..\..\..\driver\rtc\inc;..\..\..\..\kernel\util\inc;..\..\..\..\kernel\debug\src;..\..\..\..\driver\i2c\inc;..\..\..\..\driver\i2c\src\device\rtl87x3k;..\..\..\..\kernel\sys\inc;..\..\Basic\src\ap;..\..\..\..\driver\qdec\inc;..\..\..\..\driver\rtc\inc;..\..\..\..\driver;..\..\..\driver\wdt\inc;..\..\..\..\kernel\os\freertos\inc\rtl87x3k;..\..\..\driver\gtc\inc;..\..\..\..\kernel\os\osif\inc;..\..\..\..\kernel\os\freertos\V11.2.0\inc;..\..\..\..\kernel\logging\inc;..\..\..\..\kernel\debug\inc\rtl87x3k;..\..\..\..\driver\spi\inc;..\..\..\..\driver\spi\src\device\rtl87x3k;..\..\..\..\driver\led\inc;..\..\..\..\driver\led\src\device\rtl87x3k;..\..\..\..\driver\ir\inc;..\..\..\..\driver\ir\src\device\rtl87x3k;..\..\..\driver\timer\src\device\rtl87x3k;..\..\..\..\driver\gpio\inc;..\..\..\..\kernel\debug\inc;..\..\..\..\driver\lpc\inc;..\..\..\..\driver\lpc\src\device\rtl87x3k;..\..\..\driver\timer\inc;..\..\src\peripheral\ap\sd;..\..\..\driver\spi3w_m\inc;..\..\..\driver\pinmux\inc\rtl87x2j;..\..\..\hw_mutex\inc;..\..\..\driver\debug\inc;..\..\..\boot;..\..\..\driver\d2a\inc;..\..\..\..\driver\adp\inc;..\..\..\driver\gpio\inc;..\..\..\..\kernel\sys\inc\rtl87x3k;..\..\..\..\kernel\sys\src\rtl87x3k;..\..\..\driver\adp\inc;..\..\src\pm;..\..\..\..\subsys\sd\inc;..\..\..\driver\sdhc\inc;..\..\..\..\subsys\sd\src
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app_rom.sct
  link misc: --pad=0xff --diag_suppress=L6314,6480 --datacompressor=off --no_remove --entry=Reset_Handler --startup=Reset_Handler
  group arch
    ../../../../kernel/arch/arm/core_m/common/src/: interrupt.c
  group platform
    ../../../../kernel/soc/rtl87x3k/ap/: vector_table_auto_gen.c vector_table.c
    ../../../boot/: patch_os.c
    ../../src/peripheral/ap/: os_cfg.c platform_utils.c
    ../../src/system_init/src/ap/: system_bb3.c
    ../../../../kernel/debug/src/rtl87x3k/: assert_handler.c dbg_cfg.c
    ../../../boot/ap_boot/src/: rom_cfg.c stdlib_wrapper.c patch_platform.c
    ../../../../kernel/util/src/: atomic.c
    ../../../../kernel/sys/src/sys_reset/: sys_reset.c
    ../../../../kernel/sys/src/sys_reset/sys_reset_port/rtl87x3k/: sys_reset_port.c
    ../../../../kernel/sys/src/sys_reset/reset_reason/rtl87x3k/: reset_reason.c
    ../../src/pm/: pm.c
  group peripheral
    ../../../driver/pinmux/src/device/rtl87x3k/: rtl_pinmux.c rtl_wakeup.c
    ../../../driver/uart/src/device/rtl87x3k/: rtl_uart_int.c
    ../../../driver/uart/src/device/rtl_common/: rtl_uart.c
    ../../../driver/irq/src/device/rtl87x3k/: rtl_nvic.c
    ../../../driver/rcc/src/device/rtl87x3k/: rtl_rcc.c
    ../../../driver/dma/src/device/rtl_common/: rtl_dma.c
    ../../../driver/dma/src/device/rtl87x3k/: rtl_dma_int.c
    ../../../driver/rtc/src/device/rtl_common/: rtl_grtc.c
    ../../../driver/rtc/src/device/rtl87x3k/: rtl_grtc_int.c
    ../../../../driver/i2c/src/device/rtl_common/: rtl_i2c.c
    ../../../../driver/i2c/src/device/rtl87x3k/: rtl_i2c_int.c
    ../../../../driver/rtc/src/device/rtl_common/: rtl_rtc.c
    ../../../../driver/rtc/src/device/rtl87x3k/: rtl_rtc_int.c
    ../../../../driver/qdec/src/device/rtl_common/: rtl_lpqdec.c
    ../../../../driver/qdec/src/device/rtl87x3k/: rtl_lpqdec_int.c
    ../../../driver/wdt/src/device/rtl87x3k/: rtl_wdt.c
    ../../../../driver/spi/src/device/rtl_common/: rtl_spi.c
    ../../../../driver/spi/src/device/rtl87x3k/: rtl_spi_int.c
    ../../../../driver/led/src/device/rtl_common/: rtl_lpled.c
    ../../../../driver/led/src/device/rtl87x3k/: rtl_lpled_int.c
    ../../../../driver/ir/src/device/rtl_common/: rtl_ir.c
    ../../../../driver/ir/src/device/rtl87x3k/: rtl_ir_int.c
    ../../../driver/timer/src/device/rtl87x3k/: rtl_timer.c rtl_timer_int.c
    ../../../../driver/lpc/src/device/rtl87x3k/: rtl_lpc.c
    ../../../driver/spi3w_m/src/device/rtl_common/: rtl_spi3w_m.c
    ../../../driver/spi3w_m/src/device/rtl87x3k/: rtl_spi3w_m_int.c
    ../../../driver/gtc/src/device/rtl_common/: rtl_gtc.c
    ../../../driver/gpio/src/device/rtl87x3k/: rtl_gpio.c rtl_gpio_int.c
    ../../../driver/adp/src/device/rtl_common/: rtl_adp.c
  group hal
    ../../../driver/dma/src/hal/: hal_dma.c
    ../../../driver/wdt/src/device/rtl87x3k/: hal_wdt.c
    ../../../../driver/gpio/src/device/rtl87x3k/: hal_gpio_int.c
    ../../../driver/uart/src/hal/: hal_uart.c
    ../../../driver/debug/src/device/rtl87x3k/: debug_port.c
    ../../src/peripheral/sample/spi3w_m/: spi3w_m_demo.c
    ../../../driver/d2a/src/device/rtl87x3k/: d2a_access.c
    ../../../../driver/adp/src/device/rtl_common/: adp_io.c
    ../../../driver/adp/src/hal/rtl/: adapter.c
    ../../../driver/gpio/src/hal/rtl/: hal_gpio.c
  group patch
    ../../../driver/pinmux/src/device/rtl87x3k/: patch_pinmux_function.c patch_wakeup_function.c
    ../../../driver/irq/src/device/rtl87x3k/: patch_nvic_function.c
    ../../../driver/uart/src/device/rtl_common/: patch_uart_function.c patch_uart_share_function.c patch_uart_share_dma_function.c
    ../../../driver/rcc/src/device/rtl87x3k/: patch_rcc_function.c
    ../../../driver/dma/src/device/rtl_common/: patch_dma_function.c
    ../../../driver/rtc/src/device/rtl_common/: patch_grtc_function.c
    ../../../driver/gtc/src/device/rtl_common/: patch_gtc_function.c
    ../../../driver/debug/src/device/rtl87x3k/: patch_debug_port_function.c
    ../../../driver/timer/src/device/rtl87x3k/: patch_timer_function.c
    ../../../driver/uart/src/hal/: patch_hal_uart_function.c
    ../../../driver/d2a/src/device/rtl87x3k/: patch_d2a_access.c
    ../../../driver/wdt/src/device/rtl87x3k/: patch_wdt_function.c
    ../../../../kernel/logging/src/rtl87x3k/: patch_log_function.c
    ../../../driver/gpio/src/device/rtl87x3k/: patch_gpio_function.c
    ../../../driver/spi3w_m/src/device/rtl_common/: patch_spi3w_m_function.c
    ../../../../kernel/sys/src/timestamp/rtl87x3k/: patch_timestamp_function.c
    ../../../driver/adp/src/device/rtl_common/: patch_adp_function.c
    ../../../driver/adp/src/hal/rtl/: patch_adapter.c
    ../../../driver/gpio/src/hal/rtl/: patch_hal_gpio_function.c
  group log
    ../../../../kernel/logging/src/: log_format.c log_format_patch_ptr.c
    ../../../../kernel/logging/src/rtl87x3k/: log_uart.c log_format_port.c log_module.c log_uart_dma.c pingpong_buffer.c
  group os
    ../../os/freertos/: list.c event_groups.c queue.c tasks.c timers.c
    ../../os/freertos/portable/MemMang/: heap_5.c
    ../../../../kernel/os/freertos/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
    ../../../../kernel/os/freertos/portable/Timer/rtl87x3k/: freertos_grtc_timer.c
  group osif
    ../../../../kernel/os/osif/src/: os_mem.c os_msg.c os_sched.c os_sync.c os_task.c os_timer.c os_pm.c
    ../../../../kernel/sys/src/: sys_list.c
    ../../../../kernel/os/osif/src/port/freertos/: osif_freertos.c
    ../../../../kernel/os/osif/src/rtl87x3k/: os_interface.c
    ../../os/os_if/: osif_pm_grtc.c
  group main
    ../../Basic/src/ap/: main.c app_task.c
  group util
    ../../../../kernel/util/src/: utils.c
  group sys
    ../../../../kernel/sys/src/timestamp/rtl87x3k/: timestamp.c
  group sd
    ../../../../subsys/sd/src/: mmc.c sd.c sdcard.c sdio.c sdio_card.c sdmmc.c sdmmc_common.c
    ../../../driver/sdhc/src/device/rtl87x3k/: hal_sdhc.c rtl_sdmmc.c
  group peripheral_auto_test
    ../../../../driver/test/peripheral_auto_test/src/app/: app_console_msg.c app_io_msg.c app_task.c peripheral_auto_test.c test_common.c test_uart.c test_wdt.c test_dma.c test_i2c.c test_gpio.c test_spi.c
  group console
    ../../../../driver/console/src/rtl87x3k/: console_uart.c
    ../../../../subsys/console/src/: cli_core.c console.c
  group sample
    ../../src/peripheral/sample/uart/: uart_dma.c
    ../../src/peripheral/sample/dma/: dma_mem_to_mem.c
    ../../src/peripheral/sample/gpio/hal_gpio/: hal_gpio_input_demo.c hal_gpio_output_demo.c
    ../../src/peripheral/sample/gpio/gpio/: gpio_input_demo.c gpio_output_demo.c
    ../../src/peripheral/sample/uart/hal_uart/: hal_uart_trx_demo.c hal_uart_trx_dma_demo.c
    ../../src/peripheral/sample/grtc/: grtc_demo.c
    ../../src/peripheral/sample/adp/: adapter_demo.c
target PERIPHERAL_AUTO_TEST (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.0.0
  cpu: as above
  output: ROM
  AfterMake: after_build.bat $J #L @L
  c flags: Optim=7 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X3K,CONFIG_SOC_CORE_APPPROCESSOR CONFIG_LOGGING_BUFFER_LOG CONFIG_LOGGING_MINIMIZE_BOOT_LOG RAM_PROJECT_SUPPORT_FREERTOS PERIPHERAL_AUTO_TEST
  c misc: --include rom_defines.h --include cpu_setting.h -gdwarf-3 --include console_log.h
  c include: ..\..\src\peripheral\ap;..\..\..\..\kernel\arch\common;..\..\..\..\kernel\soc\rtl87x3k;..\..\..\..\kernel\staging\rtl87x3k\inc\ap;..\..\..\driver\pinmux\inc;..\..\..\driver;..\..\..\boot\ap_boot\inc;..\..\..\..\kernel\logging\inc\rtl87x3k;..\..\..\..\kernel\linker\inc;..\..\..\..\kernel\logging\src\rtl87x3k;..\..\..\..\kernel\logging\src;..\..\..\..\kernel\arch\arm\cmsis\CMSIS_5-5.9.0\CMSIS\Core\Include;..\..\..\driver\irq\inc;..\..\..\driver\rcc\inc;..\..\..\driver\uart\inc;..\..\..\driver\dma\inc;..\..\..\driver\pinmux\inc;..\..\..\driver\utils;..\..\..\..\kernel\debug\src;..\..\..\..\kernel\soc\rtl87x3k\ap;..\..\..\..\boards\boot\inc;..\..\..\..\boards\boot\inc\rtl87x3k;..\..\..\..\kernel\memory;..\..\..\..\kernel\util\inc\rtl87x3k;.\inc;..\..\src\system_init\inc;..\..\os\freertos\portable\GCC\ARM_CM33_NTZ;..\..\os;..\..\..\driver\pinmux\src\device\rtl87x3k;..\..\..\driver\rcc\src\device\rtl87x3k;..\..\..\driver\rtc\inc;..\..\..\..\kernel\util\inc;..\..\..\..\kernel\debug\src;..\..\..\..\driver\i2c\inc;..\..\..\..\driver\i2c\src\device\rtl87x3k;..\..\..\..\kernel\sys\inc;..\..\..\..\driver\qdec\inc;..\..\..\..\driver\rtc\inc;..\..\..\..\driver;..\..\..\driver\wdt\inc;..\..\..\..\kernel\os\freertos\inc\rtl87x3k;..\..\..\driver\gtc\inc;..\..\..\..\kernel\os\osif\inc;..\..\..\..\kernel\os\freertos\V11.2.0\inc;..\..\..\..\kernel\logging\inc;..\..\..\..\kernel\debug\inc\rtl87x3k;..\..\..\..\driver\spi\inc;..\..\..\..\driver\spi\src\device\rtl87x3k;..\..\..\..\driver\led\inc;..\..\..\..\driver\led\src\device\rtl87x3k;..\..\..\..\driver\ir\inc;..\..\..\..\driver\ir\src\device\rtl87x3k;..\..\..\driver\timer\src\device\rtl87x3k;..\..\..\..\kernel\debug\inc;..\..\..\..\driver\lpc\inc;..\..\..\..\driver\lpc\src\device\rtl87x3k;..\..\..\driver\timer\inc;..\..\src\peripheral\ap\sd;..\ap;..\..\..\..\driver\console\inc;..\..\..\..\driver\console\src\rtl87x3k;..\..\..\..\driver\test\peripheral_auto_test\inc\app;.\pat_override;..\..\..\..\driver\test\peripheral_auto_test\inc\platform\rtl87x3k;..\..\..\driver\spi3w_m\inc;..\..\..\driver\pinmux\inc\rtl87x2j;..\..\..\hw_mutex\inc;..\..\..\driver\debug\inc;..\..\..\boot;..\..\..\driver\d2a\inc;..\..\..\..\driver\adp\inc;..\..\..\driver\gpio\inc;..\..\..\..\kernel\sys\inc\rtl87x3k;..\..\..\..\kernel\sys\src\rtl87x3k;..\..\..\driver\adp\inc;..\..\..\..\subsys\console\inc;..\..\..\..\subsys\logging\inc;..\..\src\pm
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app_rom.sct
  link misc: as above
